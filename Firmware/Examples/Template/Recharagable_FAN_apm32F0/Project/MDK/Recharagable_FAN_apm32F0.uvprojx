# Keil uVision project Recharagable_FAN_apm32F0.uvprojx, settings and files
target Template (6190000::V6.19::ARMCLANG)
  device: APM32F003F6 Geehy
  pack: Geehy.APM32F00x_DFP.1.0.4
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Recharagable_FAN_apm32F0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Include;..\..\..\..\..\Board;..\..\..\..\..\Library\APM32F00x_StdPeriphDriver\inc;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Geehy\APM32F00x\Include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F00x/Source/: system_apm32f00x.c
    ../../../../../Library/Device/Geehy/APM32F00x/Source/ARM/: startup_apm32f0xx.s
  group StdPeriphDriver
    ../../../../../Library/APM32F00x_StdPeriphDriver/src/: apm32f00x_eint.c apm32f00x_gpio.c apm32f00x_misc.c apm32f00x_rcm.c apm32f00x_adc.c apm32f00x_buzzer.c apm32f00x_fmc.c apm32f00x_i2c.c apm32f00x_iwdt.c apm32f00x_spi.c apm32f00x_tmr1.c apm32f00x_tmr2.c apm32f00x_tmr4.c apm32f00x_usart.c apm32f00x_wupt.c apm32f00x_wwdt.c
  group Board
    ../../../../../Board/: Board.c
    ../../../../../Board/Usart/: usart_app.c
    ../../../../../Board/Timer/: time.c
    ../../../../../Board/delay/: delay.c
    ../../../../../Board/Fan/: fan.c
    ../../../../../Board/Battery/: battery.c
    ../../../../../Board/Remote/: remote.c
    ../../../../../Board/Button/: button.c
    ../../../../../Board/ADC/: adc.c
    ../../../../../Board/utility/: utility.c
    ../../../../../Board/Flash/: flash.c
  group Application
    ../../Source/: main.c apm32f00x_int.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
