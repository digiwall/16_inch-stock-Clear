<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TMR2_SinglePulse.ewp</path>
    </project>
    <batchBuild />
</workspace>
