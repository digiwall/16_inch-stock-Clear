# Keil uVision project IAP_BootLoader.uvprojx, settings and files
target APM32F00x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F003F6 Geehy
  pack: Geehy.APM32F00x_DFP.1.0.4
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IAP_BootLoader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\..\Library\APM32F00x_StdPeriphDriver\inc;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Geehy\APM32F00x\Include;..\..\Include;..\..\..\..\..\Board;..\..\..\..\..\Board\Board_APM32F002_MINI
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F00x/Source/: system_apm32f00x.c
    ../../../../../Library/Device/Geehy/APM32F00x/Source/ARM/: startup_apm32f0xx.s
  group StdPeriphDriver
    ../../../../../Library/APM32F00x_StdPeriphDriver/src/: apm32f00x_gpio.c apm32f00x_eint.c apm32f00x_adc.c apm32f00x_buzzer.c apm32f00x_fmc.c apm32f00x_i2c.c apm32f00x_iwdt.c apm32f00x_misc.c apm32f00x_rcm.c apm32f00x_spi.c apm32f00x_tmr1.c apm32f00x_tmr2.c apm32f00x_tmr4.c apm32f00x_usart.c apm32f00x_wupt.c apm32f00x_wwdt.c
  group Board
    ../../../../../Board/: Board.c
  group Application
    ../../Source/: apm32f00x_int.c main.c common.c ymodem.c menu.c
  group Bsp
    ../../Source/: bsp_usart.c bsp_flash.c
