# IAR project IAP_BootLoader.ewp, settings and files
configuration APM32F003 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F003F6 Geehy APM32F003F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Board; ..\..\..\..\..\Board\Board_APM32F003_MINI; ..\..\..\..\..\Library\Device\Geehy\APM32F00x\Include; ..\..\..\..\..\Library\APM32F00x_StdPeriphDriver\inc; ..\..\..\..\..\Library\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAP_BootLoader.srec
  ILINK.IlinkOutputFile: IAP_BootLoader.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f00x_int.c common.c main.c menu.c ymodem.c
  group Board
    ../../../../../Board/: Board.c
  group Bsp
    ../../Source/: bsp_flash.c bsp_usart.c
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F00x/Source/iar/: startup_apm32f0xx.s
    ../../../../../Library/Device/Geehy/APM32F00x/Source/: system_apm32f00x.c
  group StdPeriphLib
    ../../../../../Library/APM32F00x_StdPeriphDriver/src/: apm32f00x_adc.c apm32f00x_buzzer.c apm32f00x_eint.c apm32f00x_fmc.c apm32f00x_gpio.c apm32f00x_i2c.c apm32f00x_iwdt.c apm32f00x_misc.c apm32f00x_rcm.c apm32f00x_spi.c apm32f00x_tmr1.c apm32f00x_tmr2.c apm32f00x_tmr4.c apm32f00x_usart.c apm32f00x_wupt.c apm32f00x_wwdt.c
